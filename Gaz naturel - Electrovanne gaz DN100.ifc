Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-10-18T17:14:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 18 17:14:01 2018 * Host: JB-MSI * Database: C:\Users\JB\AppData\Local\Temp\{4821C29C-7C9C-4411-9F9D-20B3786BA480}\ifc * Database version: 5507 * Database creation date: Thu Oct 18 17:13:59 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 18 17:14:00 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 18 17:14:00 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowController: DN 100, Gaz naturel – Electrovanne gaz:DN 100:206072
In: Niveau 1
Type - Material: Métal
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Gaz naturel – Electrovanne gaz
Type - Données d'identification(Type) - Nom du type: DN 100
Pset_DistributionFlowElementCommon - Reference: DN 100
Autre - Catégorie: Accessoire de canalisation; Famille: Gaz naturel – Electrovanne gaz: DN 100; Famille et type: Gaz naturel – Electrovanne gaz: DN 100; ID du type: Gaz naturel – Electrovanne gaz: DN 100; Type: Gaz naturel – Electrovanne gaz: DN 100
Contraintes - Décalage: 0 mm; Diamétre C: 254 mm; DN: 100 mm; Hauteur B: 363 mm; Hôte: Niveau : Niveau 1; Lien vers les objets génériques BIM au gaz naturel: https://cegibat.grdf.fr/dossier-techniques/conception-batiments; Longueur A: 350 mm; Matériau: Métal; Niveau: Niveau: Niveau 1; Pression max: 0 Pa; Température max: 0 kg/K/s3; Température min: 0 kg/K/s3
Cotes - Débord: 337.143 mm; DEBORD10: 20 mm; Debord2: 80 mm; Debord3: 50 mm; DEBORD4: 217.143 mm; DIAM 2: 180 mm; DIAM 3: 84.6667 mm; DIAM 5: 28.2222 mm; DN Bloque: 100 mm; RAY 3: 42.3333 mm; Surface: 0.278715 m2; Taille: 100 mmø-100 mmø; Taille maximale: 100 mm; Taille minimale: 100 mm; Volume: 0.0139701 m3
Données d'identification - Identifiant: 9
Génie climatique - Classification du système: Non défini
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 100 mmø-100 mmø
Phase de construction - Phase de création: Nouvelle construction
